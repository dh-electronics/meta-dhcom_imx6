include u-boot-imx6-dhcom.inc

PV = "v1.0.0.6"

# use latest source
SRCREV = "${AUTOREV}"
#LOCALVERSION = "-v1.0.0.6"
#SRCBRANCH = "patches-2014.10"
