include u-boot-imx6-dhcom.inc

PV = "v1.0.0.4"

# use latest source
SRCREV = "${AUTOREV}"
#LOCALVERSION = "-v1.0.0.4"
#SRCBRANCH = "patches-2014.10"
