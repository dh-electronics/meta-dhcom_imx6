include u-boot-imx6-dhcom.inc

#PV = "dhv0.4.2.2+git${SRCPV}"
PV = "dhv0.4.2.2"

# use latest source
SRCREV = "${AUTOREV}"
#LOCALVERSION = "-dhv0.4.2.2"
#SRCBRANCH = "patches-2014.10"
